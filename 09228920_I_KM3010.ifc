Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 7325d85a-0370-4f64-a1bc-f3a31fea54fb, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-05T13:33:48+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 09228920_I_KM3010:26301050_I_9228920_KM3010, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 626 mm; Height: 54 mm; Depth: 526 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_Zinc_Steel, z_Miele_Design_Cast_Grey, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Gas, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 26301050_I_9228920_KM3010; sets with these values: 2

# IfcDistributionPort, Port_363866_1
Description: Flow; FlowDirection: SOURCEANDSINK
